<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtlsdrRx</value></param>
<param><key>author</key><value>Santiago Rodriguez</value></param>
<param><key>description</key><value>Preliminary result for WComm final project</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Simulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CF</value></param>
<param><key>value</key><value>920e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EBW</value></param>
<param><key>value</key><value>.3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Gain_rx</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value>Gain_rx</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>RRC_filter_taps</value></param>
<param><key>comment</key><value>Root raised cosine definition.</value></param>
<param><key>alpha</key><value>EBW</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sr</value></param>
<param><key>value</key><value>16e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'111111111111111111111111111111111111111111111111111111111111111'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'1111000011110000111100001111000011110000111100001111000011110000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>57</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'00000000000000000000000000000000'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pyl_lenght</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scale</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>2*numpy.pi/100</value></param>
<param><key>max_freq</key><value>10</value></param>
<param><key>min_freq</key><value>-10</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>16000</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>pyl_lenght</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>2**8</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>gmsk_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>2**8</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>scale</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>33</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>audio_Rx</value></param>
<param><key>samp_rate</key><value>int(audio_sr)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>label2</key><value>Const</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>comment</key><value>Channel equalizer</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mu</key><value>.01</value></param>
<param><key>modulus</key><value>.1</value></param>
<param><key>num_taps</key><value>11</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>comment</key><value>Fine carrier frequency and phase sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>w</key><value>.1</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>comment</key><value>Carrier frequency sync</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rolloff</key><value>EBW</value></param>
<param><key>w</key><value>.01</value></param>
<param><key>filter_size</key><value>45</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Timing recovery (sync)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0*2</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>RRC_filter_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>comment</key><value>Custom Embedded
Python Block uses 
this library.</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>controls@2: 0,0,1,1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>controls@1: 0,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>controls@0: 0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>CF</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>Gain_rx</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>EncodeData</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1</value></param>
<param><key>stream_id</key><value>audio_Rx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>GMSK_Tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>a_deco</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>a_source</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>pckt_decode</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>EncodeData</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>GMSK_Tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>audio_Rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>a_source</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>pckt_decode</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>a_deco</value></param>
</block>
<block>
<key>vocoder_codec2_decode_ps</key>
<param><key>id</key><value>vocoder_codec2_decode_ps_0</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_cvsd_decode_bs</key>
<param><key>id</key><value>vocoder_cvsd_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_g723_24_decode_bs</key>
<param><key>id</key><value>vocoder_g723_24_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_g723_40_decode_bs</key>
<param><key>id</key><value>vocoder_g723_40_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_gsm_fr_decode_ps</key>
<param><key>id</key><value>vocoder_gsm_fr_decode_ps_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_ulaw_decode_bs</key>
<param><key>id</key><value>vocoder_ulaw_decode_bs_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>vocoder_gsm_fr_decode_ps_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>vocoder_codec2_decode_ps_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>virtual_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>vocoder_cvsd_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>vocoder_g721_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>vocoder_g723_24_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>vocoder_g723_40_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>vocoder_ulaw_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_decode_ps_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_cvsd_decode_bs_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g723_24_decode_bs_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g723_40_decode_bs_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_gsm_fr_decode_ps_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_ulaw_decode_bs_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
