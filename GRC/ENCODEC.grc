<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>encodec</value></param>
<param><key>author</key><value>SAGO</value></param>
<param><key>description</key><value>ecoder-mod-demod-decoder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>encodec simulation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pyl_lenght</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>pyl_lenght</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>DataOut</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>encoData</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>file</key><value>gmskDemod</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>data_in.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>fmdemod.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq</value></param>
<param><key>label2</key><value>Const</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>log</key><value>True</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>log</key><value>True</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>controls@2: 0,0,1,1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>controls@1: 0,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>controls@0: 0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>GMSK_Tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>EncoData</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>GMSK_Rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>GMSK_Tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>EncoData</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>EncoData</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>GMSKDemod</value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
